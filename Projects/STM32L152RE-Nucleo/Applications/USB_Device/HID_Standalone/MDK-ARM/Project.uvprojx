# Keil uVision project Project.uvprojx, settings and files
target STM32L1_Nucleo (ARM-ADS)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L1_Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L152xE,USE_HAL_DRIVER,USE_STM32L1xx_NUCLEO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L1xx_Nucleo;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_cortex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc_ex.c
  group Middlewares/STM32_USBD_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Application/User
    ../Src/: usbd_desc.c usbd_conf.c main.c stm32l1xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Doc
    ../: readme.txt
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
software components: CMSIS:CORE 4.1.0
