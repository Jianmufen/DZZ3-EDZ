# Keil uVision project Project.uvprojx, settings and files
target STM32L152D_EVAL (ARM-ADS)
  device: STM32L152ZD STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152D_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L152xD,USE_HAL_DRIVER,USE_STM32L152D_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32L152D_EVAL;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Utilities\Log;..\..\..\..\..\Utilities\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32l152xd.s
  group Example/User
    ../Src/: stm32l1xx_it.c nor.c audio_record.c main.c sram.c audio_play.c log.c eeprom.c sd.c temperature_sensor.c joystick.c lcd.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
    ../../../../../Drivers/BSP/Components/stlm75/: stlm75.c
    ../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_opamp_ex.c stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_sd.c stm32l1xx_hal_spi_ex.c stm32l1xx_ll_sdmmc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_spi.c stm32l1xx_hal_i2s.c stm32l1xx_hal_rcc.c stm32l1xx_hal_opamp.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_i2c.c stm32l1xx_hal_nor.c stm32l1xx_hal_dma.c stm32l1xx_ll_fsmc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_adc.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
  group Drivers/BSP/STM32L152D_EVAL
    ../../../../../Drivers/BSP/STM32L152D_EVAL/: stm32l152d_eval_audio.c stm32l152d_eval_eeprom.c stm32l152d_eval_lcd.c stm32l152d_eval_sd.c stm32l152d_eval_nor.c stm32l152d_eval_sram.c stm32l152d_eval_tsensor.c stm32l152d_eval.c
software components: CMSIS:CORE 4.1.0
