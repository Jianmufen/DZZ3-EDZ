# Keil uVision project Project.uvprojx, settings and files
target STM32L152C-Discovery (ARM-ADS)
  device: STM32L152RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152C-Discovery +hex
  AfterMake: E:\ruanjian\MDK5\ARM\ARMCC\bin\fromelf.exe      --bin -o   C:\Users\Administrator\Desktop\Application\2017-09-29\STM32Cube_FW_L1_V1.6.0\Projects\NMDT_ADAM\Applications\FreeRTOS\FreeRTOS_ThreadCreation\MDK-ARM\STM32L152C-Discovery\STM32L152C-Discovery.bin    C:\Users\Administrator\Desktop\Application\2017-09-29\STM32Cube_FW_L1_V1.6.0\Projects\NMDT_ADAM\Applications\FreeRTOS\FreeRTOS_ThreadCreation\MDK-ARM\STM32L152C-Discovery\STM32L152C-Discovery.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xC,USE_STM32L152C_DISCO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L152C-Discovery;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\..\..\Drivers\BSP\Adafruit_Shield
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c list.c timers.c queue.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application/MDK-ARM
    ./: startup_stm32l152xc.s
  group Drivers/BSP/STM32L152C-Discovery
    ../../../../../../Drivers/BSP/STM32L152C-Discovery/: stm32l152c_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Application/User
    ../Src/: display_module.c sys_time_module.c usart_module.c storage_moudle.c main.c stm32l1xx_it.c usart.c rtc.c pcf8563.c iwdg.c time_related.c sd_io_low.c i2c.c tim.c LCM_DRIVE.c button.c Font12_16_16.c adc.c ds18b20.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_cortex.c stm32l1xx_hal.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_dma.c stm32l1xx_hal_i2c.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_ll_sdmmc.c stm32l1xx_ll_spi.c stm32l1xx_ll_usart.c stm32l1xx_ll_rtc.c stm32l1xx_ll_rcc.c stm32l1xx_ll_pwr.c stm32l1xx_ll_gpio.c stm32l1xx_ll_i2c.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_sd.c
software components: CMSIS:CORE 4.1.0
