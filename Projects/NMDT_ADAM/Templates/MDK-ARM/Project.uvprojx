# Keil uVision project Project.uvprojx, settings and files
target STM32L152C-Discovery (ARM-ADS)
  device: STM32L152RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152C-Discovery +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xC,USE_STM32L152C_DISCO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32L152C-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L152C-Discovery
    ../../../../Drivers/BSP/STM32L152C-Discovery/: stm32l152c_discovery.c
  group Example/User
    ../Src/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c at_iic.c at24c512.c gpio.c key.c lcd.c pcf8563.c rtc.c usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Example/MDK-ARM
    ./: startup_stm32l152xc.s
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_cryp.c stm32l1xx_hal_uart.c stm32l1xx_hal_rcc.c stm32l1xx_hal_irda.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_i2s.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_flash.c stm32l1xx_hal_comp.c stm32l1xx_hal_tim.c stm32l1xx_ll_sdmmc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_sram.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dac.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pcd.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_usart.c stm32l1xx_hal_lcd.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_opamp.c stm32l1xx_hal_sd.c stm32l1xx_ll_fsmc.c stm32l1xx_hal_nor.c stm32l1xx_hal_wwdg.c stm32l1xx_hal_crc.c stm32l1xx_hal_i2c.c stm32l1xx_hal_rtc.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_adc.c
software components: CMSIS:CORE 4.1.0
